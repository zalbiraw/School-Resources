	AREA prog2, code, READONLY
	ENTRY
	LDR R0,X ; LOAD X VALUE INTO R0
	BL QUAD ; START SUB ROUTINE
	MOV R1,R0,LSL#1 ; MOVE THE VALUE RETURNED * 2 INTO R1
MAINEND B MAINEND 
QUAD STMFD sp!,{R1-R8} ; STORE THE VALUES OF THE REGISTERS TO BE USED
	LDR R1,A ; LOAD A INTO R1
	LDR R2,B ; LOAD B INTO R2
	LDR R3,C ; LOAD C INTO R3
	LDR R4,D ; LOAD D INTO R4
	MLA R6,R2,R0,R3 ; CALCULATE B * X + C AND STORING IT ON R6
	MUL R7,R0,R0 ; CALCULATE X ^ 2 AND STORE IT IN R7
	MLA R8,R7,R1,R6 ; MULTIPLY A BY X ^ 2 AND ADD B * X + C STORED IN R6 - RESULT STORED IN R8
	CMP R8,R4 ; COMPARING Y AND D
 	MOVGT R0,R4 ; MOVE D INTO R0
	MOVLE R0,R8 ; MOVE Y INTO R0
	LDMFD sp!,{R1-R8} ; RESTORE REGISTER VALUES 
 	MOV R15,R14 ; RETURN FROM SUBROUTINE
	AREA data, DATA
A DCD 5 ; A VALUE
B DCD 6 ; B VALUE
C DCD 7 ; C VALUE
D DCD 90 ; D VALUE
X DCD 3 ; X VALUE
STACK SPACE 0xFF ; DECLARING SPACE FOR THE STACK
	END